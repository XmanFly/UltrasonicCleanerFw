# Keil uVision project UltrasonicCleanerFw.uvproj, settings and files
target STC8H1K08 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: UltrasonicCleanerFw +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\app;.\bsp;.\drivers;.\drivers\led;.\services;.\services\anim
  group Source Group
    ./: STARTUP.A51
  group app
    ./app/: main_emb.c
  group common
    ./common/: types.h platform.h log_stub.c
  group services
    ./services/: soft_timer.c soft_timer.h touch_service.c touch_service.h led_sm.c soft_pwm.c soft_pwm.h led_group.c led_group.h led_sm.h
  group hal
    ./hal/embedded/: batt_emb.c led_emb.c time_emb.c touch_emb.c us_emb.c uart_emb.c
    ./hal/: battery.h led.h time.h touch.h ultrasonic.h uart.h
  group logic
    ./logic/: fsm.c fsm.h
